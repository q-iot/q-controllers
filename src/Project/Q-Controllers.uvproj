# Keil uVision project Q-Controllers.uvproj, settings and files
target Q-Controllers (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Q-Controllers +hex
  AfterMake: fromelf.exe --bin -o  $L@L.bin #L
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Common\Hardware;..\Common\Lib;..\Common\Lib\inc;..\Common\Storage;..\Common\Misc;..\Common\SysHandler;..\Common\SysTimer;..\Common\Include;..\Common\Q_Lib;..\Common\WNet;..\Common\Debug;..\Core\Controllers;..\Core\Include;..\Core\User;..\Core\Data;..\Core\WDev
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib
    ../Common/Lib/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c misc.c stm32f10x_dma.c
    ../Common/Lib/: system_stm32f10x.c core_cm3.c
  group Hardware
    ../Common/Hardware/: WRfDrv.c Delay.c Adc.c Spi.c Time.c Uart.c Dht11.c SpiFlash_w25q.c RomFlash.c Ir.c IrOut.c StmDevelop.c Sx1276.c Si4432.c Uart2_Dma.c
  group Misc
    ../Common/Misc/: PublicFunc.c StrParse.c
    ../Core/User/: SomeFunc.c
  group Storage
    ../Core/Data/: RomFlashSave.c
  group WNet
    ../Common/WNet/: WNetPktAttrib.c WNetPktSend.c WNetTransHandler.c WNetRecvQ.c WNetNameDebug.c
  group SysHandler
    ../Common/SysHandler/: NextLoopFunc.c EventInHandler.c ControllerHandler.c
    ../Common/SysTimer/: MsFunc.c SecFunc.c SysTimer.c
    ../Common/Q_Lib/: Q_Heap.c Q_Queue.c
  group Controllers
    ../Core/Controllers/: QComController.c QWifiController.c CollController.c LoraController.c WNetController.c LedsController.c RsComController.c
  group WDev
    ../Core/WDev/: WDevFunc.c PairDataInHanlder.c WorkMode.c
  group User
    ../Common/Misc/: IoDefines.c
    ../Core/User/: main.c startup_stm32f10x_md.s stm32f10x_it.c SysCmdHandler.c
    ../Common/Debug/: NameDebug.c
