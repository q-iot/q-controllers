# Keil uVision project Q-Controllers.uvproj, settings and files
target Q-Controllers (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Q-Controllers +hex
  AfterMake: fromelf.exe --bin -o  $L@L.bin #L
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\Common\Drivers;..\..\Common\Lib;..\..\Common\Lib\inc;..\..\Common\DataSave;..\..\Common\InfoSave;..\..\Common\Misc;..\..\Common\SysHandler;..\..\Common\SysTimer;..\Controllers;..\Include;..\User
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib
    ../../Common/Lib/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c misc.c stm32f10x_dma.c
    ../../Common/Lib/: system_stm32f10x.c core_cm3.c
  group Drivers
    ../../Common/Drivers/: Delay.c Adc.c Spi.c Time.c Uart.c Dht11.c SpiFlash_w25q.c
  group Misc
    ../../Common/Misc/: PublicFunc.c
    ../User/: SomeFunc.c
  group Storage
    ../../Common/DataSave/: RomFlashSave.c RomFlash.c
  group SysHandler
    ../../Common/SysHandler/: EventInHandler.c NextLoopFunc.c Q_Heap.c Q_Queue.c
    ../../Common/SysTimer/: MsFunc.c SecFunc.c SysTimer.c
  group Controllers
    ../Controllers/: NewController.c TestController.c
  group User
    ../User/: startup_stm32f10x_md.s main.c SysCmdHandler.c stm32f10x_it.c
    ../../Common/Misc/: IoDefines.c
